# Keil uVision project RC2022_MAIN.uvprojx, settings and files
target RC2022_MAIN (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RC2022_MAIN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c misc: --cpp11
  c include: ..\USR;..\BSP;..\TASK;..\CORE;..\FWLIB\inc;..\UCOSIII\UCOSIII_CONFIG_BSP;..\UCOSIII\UCOS_CPU;..\UCOSIII\UCOS_LIB;..\UCOSIII\UCOS_III\Ports\ARM-Cortex-M4;..\UCOSIII\UCOS_III\Source;..\API\ALGORITHM;..\API\BSP;..\API\MODULE;..\API\ROBOT;..\USR;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\netif;..\LWIP\arch;..\LWIP;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\udp_demo;..\LWIP\lwip-1.4.1\src\include\netif;..\EASYFLASH;..\GLOBAL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USR
    ../USR/: system_stm32f4xx.c stm32f4xx_it.cpp main.cpp basic_function.c hitcrt_os.h gimbal_control_types.h
  group GLOBAL
    ../GLOBAL/: flag_global.cpp flag_global.h basic_type.h global_math.h
  group TASK
    ../TASK/: motor_control_task.cpp navigation_task.cpp remote_lcd_task.cpp read_remote_ctrl_task.cpp system_monitor_task.cpp action_task.cpp debug_task.cpp
  group API/ROBOT
    ../API/ROBOT/: movement_info.cpp chassis.cpp minor_part.cpp debug_api.cpp sucker.cpp table.cpp
  group API/ALGORITHM
    ../API/ALGORITHM/: locate_algorithm.cpp math_algorithm.cpp navigation_algorithm.cpp pid_algorithm.cpp path_algorithm.cpp filter_algorithm.cpp path_discarded.cpp vision_algorithm.cpp
  group API/MODULE
    ../API/MODULE/: air_operated_board.cpp motor_drive.cpp remote_control.cpp usart_protocol.cpp E103_W06.cpp lan8720.cpp Gyro.cpp
  group BSP
    ../BSP/: bsp_init.cpp can.cpp fsmc.cpp led.cpp nvic.cpp rcc.cpp spi.cpp tim.cpp uart.cpp flash.cpp buzzer.cpp nrf.cpp
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group UCOSIII_CPU
    ../UCOSIII/UCOS_CPU/: cpu_a.asm cpu_c.c cpu.h cpu_core.c cpu_core.h cpu_def.h
  group UCOSIII_CORE
    ../UCOSIII/UCOS_III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UCOSIII_PORT
    ../UCOSIII/UCOS_III/Ports/ARM-Cortex-M4/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_LIB
    ../UCOSIII/UCOS_LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group UCOSIII_CONFIG_BSP
    ../UCOSIII/UCOSIII_CONFIG_BSP/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h ucos_bsp.c ucos_bsp.h
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/udp_demo/: udp_demo.c
  group EASY_FLASH
    ../EASYFLASH/: easyflash.c ef_env.c ef_iap.c ef_port.c ef_utils.c
