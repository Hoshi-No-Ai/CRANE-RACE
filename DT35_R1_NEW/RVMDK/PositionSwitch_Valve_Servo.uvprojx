# Keil uVision project PositionSwitch_Valve_Servo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PositionSwitch_Valve_Servo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Usr
    ../src/: main.c
  group Hal
    ../src/: GPIO.c hal.c RCC.c stm32f10x_it.c TIMER.c PositionSwitch.c CAN.c NVIC.c Valve.c ADS1256.c SPI.c
  group FWLib
    ../src/STM32Lib/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group StartUp
    ../src/STM32Lib/StartUp/: startup_stm32f10x_md.s
  group Header
    ../src/: CAN.h GPIO.h hal.h PositionSwitch.h RCC.h TIMER.h main.h NVIC.h Valve.h ADS1256.h SPI.h
software components: CMSIS:CORE 5.4.0
