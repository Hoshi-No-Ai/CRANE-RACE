# Keil uVision project RC2021_DR_MINOR.uvprojx, settings and files
target RC2021_DR_MINOR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RC2021_DR_MINOR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c misc: --cpp11
  c include: ..\USR;..\BSP;..\TASK;..\CORE;..\FWLIB\inc;..\API\ALGORITHM;..\API\MODULE;..\API\ROBOT;..\UCOSIII\UCOSIII_CONFIG_BSP;..\UCOSIII\UCOS_CPU;..\UCOSIII\UCOS_LIB;..\UCOSIII\UCOS_III\Ports\ARM-Cortex-M4;..\UCOSIII\UCOS_III\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USR
    ../USR/: system_stm32f4xx.c stm32f4xx_it.h main.cpp hitcrt_os.h stm32f4xx_it.cpp basic_type.h global_declare.h
  group TASK
    ../TASK/: system_monitor_task.cpp system_monitor_task.h transmit_task.h transmit_task.cpp action_task.cpp action_task.h
  group API/ROBOT
    ../API/ROBOT/: motor_all.cpp motor_all.h sucker.cpp sucker.h
  group API/ALGORITHM
    ../API/ALGORITHM/: filter_algorithm.cpp filter_algorithm.h pid_algorithm.h pid_algorithm.cpp math_algorithm.cpp math_algorithm.h smc_algorithm.h smc_algorithm.cpp
  group API/MODULE
    ../API/MODULE/: air_operated_board.cpp air_operated_board.h motor_drive.cpp motor_drive.h uart_protocol.cpp uart_protocol.h
  group BSP
    ../BSP/: bsp_init.c bsp_init.h can.c can.h nvic.c nvic.h rcc.c rcc.h tim.c tim.h uart.c uart.h gpio.c gpio.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c
  group UCOSIII_CPU
    ../UCOSIII/UCOS_CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group UCOSIII_CORE
    ../UCOSIII/UCOS_III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UCOSIII_PORT
    ../UCOSIII/UCOS_III/Ports/ARM-Cortex-M4/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_LIB
    ../UCOSIII/UCOS_LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group UCOSIII_CONFIG_BSP
    ../UCOSIII/UCOSIII_CONFIG_BSP/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h ucos_bsp.c ucos_bsp.h
